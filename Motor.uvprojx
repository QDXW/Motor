# Keil uVision project Motor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Motor
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Source\CORE;.\Source\FWLib\inc;.\Source\ISR;.\Source\System;.\Source\Modules\Comm;.\Source\Modules\Common;.\Source\Modules\Movement;.\Source\Modules\Motor;.\Source\Modules\Sensor
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./Source/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./Source/FWLib/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c
  group ISR
    ./Source/ISR/: stm32f10x_it.c
  group System
    ./Source/System/: main.c system_stm32f10x.c Global_variable.c
  group Modules
    ./Source/Modules/Comm/: Comm.c Comm_CAN.c Comm_CAN_FIFO.c
    ./Source/Modules/Common/: Common.c
    ./Source/Modules/Movement/: Movement.c
    ./Source/Modules/Motor/: Motor.c
    ./Source/Modules/Sensor/: sensor.c
